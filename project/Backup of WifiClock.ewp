# IAR project Backup of WifiClock.ewp, settings and files
configuration WifiClock (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051x8 ST STM32F051x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F051x8; _DEBUG_PRINT
  ICCARM.CCIncludePath2: ..\main; ..\Drivers\STM32F0xx_HAL_Driver\Inc; ..\sys\iap; ..\sys\json; ..\sys\usmart; ..\user\common\inc; ..\user\hardware\inc; ..\Drivers\CMSIS\Device\ST\STM32F0xx\Include; ..\Drivers\CMSIS\Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: WifiClock.hex
  ILINK.IlinkOutputFile: WifiClock.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f051x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/hardware
    ../user/hardware/src/: adc.c crc.c dma.c gpio.c i2c.c i2s.c iwdg.c rtc.c spi.c tim.c usart.c
  group Application/main
    ../main/: main.c stm32f0xx_hal_msp.c stm32f0xx_it.c
  group Application/user
    ../user/common/src/: comment.c delay.c display.c temperature.c w25xflash.c wav.c wifi.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f051x8.s
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_can.c stm32f0xx_hal_cec.c stm32f0xx_hal_comp.c stm32f0xx_hal_cortex.c stm32f0xx_hal_crc.c stm32f0xx_hal_crc_ex.c stm32f0xx_hal_dac.c stm32f0xx_hal_dac_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_i2s.c stm32f0xx_hal_irda.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_pcd.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_tsc.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_usart.c stm32f0xx_hal_wwdg.c
  group Readme
    ../doc/: WifiClock.txt wifi配网流程.txt 与服务器通信协议.md 存储空间分配.md 调试说明.txt
  group System/iap
    ../sys/iap/: iap.c
  group System/json
    ../sys/json/: cJSON.c
  group System/usmart
    ../sys/usmart/: smart_uart.c
